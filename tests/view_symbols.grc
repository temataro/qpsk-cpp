options:
  parameters:
    generate_options: qt_gui
    id: view_symbols
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 180 / 3.14159265
    type: float
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_1
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_2
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tem/code/github.com/temataro/qpsk-cpp/data/4-ary_Map/sine_00.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/tem/code/github.com/temataro/qpsk-cpp/data/4-ary_Map/sine_01.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/tem/code/github.com/temataro/qpsk-cpp/data/4-ary_Map/sine_02.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: /home/tem/code/github.com/temataro/qpsk-cpp/data/4-ary_Map/sine_03.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Convert radians to degrees
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    comment: Convert radians to degrees
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    comment: Convert radians to degrees
    type: float
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    comment: Convert radians to degrees
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Relative Phases of Each Signal"'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Magnitudes of Each signal"'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_const_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_const_source_x_0, '0', blocks_multiply_xx_0_1, '1']
- [analog_const_source_x_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_multiply_xx_0_2, '0']
- [blocks_complex_to_magphase_0_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_complex_to_magphase_0_0, '1', blocks_multiply_xx_0_1, '0']
- [blocks_complex_to_magphase_0_1, '0', qtgui_time_sink_x_0_1_0, '2']
- [blocks_complex_to_magphase_0_1, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_magphase_0_2, '0', qtgui_time_sink_x_0_1_0, '3']
- [blocks_complex_to_magphase_0_2, '1', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_throttle2_0_1, '0']
- [blocks_file_source_0_2, '0', blocks_throttle2_0_2, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_1, '3']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_0_1, '2']
- [blocks_multiply_xx_0_1, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_multiply_xx_0_2, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_throttle2_0_0, '0', blocks_complex_to_magphase_0_0, '0']
- [blocks_throttle2_0_1, '0', blocks_complex_to_magphase_0_1, '0']
- [blocks_throttle2_0_2, '0', blocks_complex_to_magphase_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
